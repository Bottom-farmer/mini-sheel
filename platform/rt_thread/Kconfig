## platform/rt_thread/Kconfig
```kconfig
menuconfig PKG_USING_MINI_SHEEL
    bool "mini-sheel for RT-Thread"
    default n
```
